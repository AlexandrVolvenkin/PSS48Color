# IAR project PSS48.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x400
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128a ATmega128A
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.newCCIncludePaths: D:\Projects\CurrentProjects\CautoProjects\PSS48Color\Modbus; D:\Projects\CurrentProjects\CautoProjects\PSS48Color\include
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  ICCAVR.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128a.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCNearHeapSize: 0x20
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    src/: Alarm.cpp AlarmWindow.cpp Buzzer.cpp Crc.cpp DataBase.cpp DataStore.cpp Dfa.cpp DM134.cpp Event.cpp HammingCodes.cpp InputDevice.cpp LightBoard.cpp LinkControl.cpp main.cpp ModuleMrXX.cpp Mvsn21.cpp NotifyerControl.cpp Platform.cpp Pss21.cpp Timer.cpp
    Modbus/: modbus.cpp ModbusRTU.cpp
